MYROBOT_LAYOUT_DIR := "${THISDIR}/files"
PARTITION_FILE = "${MYROBOT_LAYOUT_DIR}/${PARTITION_LAYOUT_TEMPLATE}"
do_install[file-checksums] += "${PARTITION_FILE}:True"
